# IAR project Backup of Motor_demo.ewp, settings and files
configuration Motor_demo (ARM, debug)
  General.OGChipSelectEditMenu: STM32G431RB ST STM32G431RB
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 6
  ICCARM.CCDefines: ARM_MATH_CM4; USE_FULL_LL_DRIVER; USE_HAL_DRIVER; STM32G431xx
  ICCARM.CCIncludePath2: ../Inc; ../Drivers/STM32G4xx_HAL_Driver/Inc; ../Drivers/STM32G4xx_HAL_Driver/Inc/Legacy; ../MCSDK_v6.2.1-Full/MotorControl/MCSDK/MCLib/Any/Inc; ../MCSDK_v6.2.1-Full/MotorControl/MCSDK/MCLib/G4xx/Inc; ../Drivers/CMSIS/Device/ST/STM32G4xx/Include; ../Drivers/CMSIS/Include; ../Drivers/CMSIS/DSP/Include
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 2
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Motor_demo.hex
  ILINK.IlinkOutputFile: Motor_demo.out
  ILINK.IlinkIcfFile: stm32g431xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/EWARM
    ./: startup_stm32g431xx.s
  group Application/User
    ../Src/: main.c motorcontrol.c mc_api.c mc_config.c mcp_config.c mc_tasks.c pwm_curr_fdbk.c regular_conversion_manager.c mc_math.c mc_interface.c stm32g4xx_mc_it.c mc_parameters.c register_interface.c mcp.c mc_perf.c usart_aspep_driver.c mc_configuration_registers.c aspep.c mc_app_hooks.c stm32g4xx_it.c stm32g4xx_hal_msp.c
  group Drivers/STM32G4xx_HAL_Driver
    ../Drivers/STM32G4xx_HAL_Driver/Src/: stm32g4xx_ll_utils.c stm32g4xx_ll_exti.c stm32g4xx_ll_gpio.c stm32g4xx_ll_adc.c stm32g4xx_ll_dma.c stm32g4xx_hal.c stm32g4xx_hal_rcc.c stm32g4xx_hal_rcc_ex.c stm32g4xx_hal_flash.c stm32g4xx_hal_flash_ex.c stm32g4xx_hal_flash_ramfunc.c stm32g4xx_hal_gpio.c stm32g4xx_hal_exti.c stm32g4xx_hal_dma.c stm32g4xx_hal_dma_ex.c stm32g4xx_hal_pwr.c stm32g4xx_hal_pwr_ex.c stm32g4xx_hal_cortex.c stm32g4xx_ll_cordic.c stm32g4xx_hal_tim.c stm32g4xx_hal_tim_ex.c stm32g4xx_ll_tim.c stm32g4xx_ll_usart.c stm32g4xx_ll_rcc.c
  group Drivers/CMSIS
    ../Src/: system_stm32g4xx.c
  group Middlewares/MotorControl
    ../MCSDK_v6.2.1-Full/MotorControl/libMP/: libmp-G4-IAR_ARMv7-M.a
    ../MCSDK_v6.2.1-Full/MotorControl/MCSDK/MCLib/Any/Src/: bus_voltage_sensor.c circle_limitation.c digital_output.c ntc_temperature_sensor.c open_loop.c pid_regulator.c pqd_motor_power_measurement.c pwm_common.c r_divider_bus_voltage_sensor.c ramp_ext_mngr.c revup_ctrl.c speed_pos_fdbk.c speed_torq_ctrl.c sto_pll_speed_pos_fdbk.c virtual_speed_sensor.c mcpa.c
    ../MCSDK_v6.2.1-Full/MotorControl/MCSDK/MCLib/G4xx/Src/: r3_1_g4xx_pwm_curr_fdbk.c
